FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
file://i2c.cfg \
file://inkernel_config.cfg \
"