FILESEXTRAPATHS:prepend := "${THISDIR}/${MACHINE}:"

SRC_URI:append = " file://fitimage.cfg file://maxsize.cfg"