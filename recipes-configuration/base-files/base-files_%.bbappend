do_install:append() {
    rm -f ${D}${sysconfdir}/motd
}